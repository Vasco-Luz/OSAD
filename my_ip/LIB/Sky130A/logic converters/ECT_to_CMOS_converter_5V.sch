v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 1700 -440 2040 -440 {}
L 4 2040 -440 2040 -400 {}
L 4 1700 -400 2040 -400 {}
L 4 1700 -440 1700 -400 {}
L 4 1860 -440 1860 -400 {}
L 4 1700 -400 2040 -400 {}
L 4 2040 -400 2040 -360 {}
L 4 1700 -360 2040 -360 {}
L 4 1700 -400 1700 -360 {}
L 4 1860 -400 1860 -360 {}
L 4 1700 -360 2040 -360 {}
L 4 2040 -360 2040 -320 {}
L 4 1700 -320 2040 -320 {}
L 4 1700 -360 1700 -320 {}
L 4 1860 -360 1860 -320 {}
L 4 1700 -320 2040 -320 {}
L 4 2040 -320 2040 -280 {}
L 4 1700 -280 2040 -280 {}
L 4 1700 -320 1700 -280 {}
L 4 1860 -320 1860 -280 {}
L 4 1700 -280 2040 -280 {}
L 4 1700 -280 2040 -280 {}
L 4 2040 -280 2040 -240 {}
L 4 1700 -240 2040 -240 {}
L 4 1700 -280 1700 -240 {}
L 4 1860 -280 1860 -240 {}
L 4 1700 -240 2040 -240 {}
L 4 2040 -240 2040 -200 {}
L 4 1700 -200 2040 -200 {}
L 4 1700 -240 1700 -200 {}
L 4 1860 -240 1860 -200 {}
L 4 1700 -200 2040 -200 {}
L 4 2040 -200 2040 -160 {}
L 4 1700 -160 2040 -160 {}
L 4 1700 -200 1700 -160 {}
L 4 1860 -200 1860 -160 {}
L 4 1700 -160 2040 -160 {}
L 4 2040 -160 2040 -120 {}
L 4 1700 -120 2040 -120 {}
L 4 1700 -160 1700 -120 {}
L 4 1860 -160 1860 -120 {}
L 4 1700 -120 2040 -120 {}
L 4 2040 -120 2040 -80 {}
L 4 1700 -80 2040 -80 {}
L 4 1700 -120 1700 -80 {}
L 4 1860 -120 1860 -80 {}
L 4 1700 -80 2040 -80 {}
L 4 1700 -80 2040 -80 {}
L 4 2040 -80 2040 -40 {}
L 4 1700 -40 2040 -40 {}
L 4 1700 -80 1700 -40 {}
L 4 1860 -80 1860 -40 {}
L 4 1700 -40 1700 0 {}
L 4 2040 -40 2040 0 {}
L 4 1700 0 2040 0 {}
L 4 1860 -40 1860 0 {}
L 4 1700 0 1700 40 {}
L 4 2040 0 2040 40 {}
L 4 1860 0 1860 40 {}
L 4 1700 40 2040 40 {}
L 4 1700 40 1700 80 {}
L 4 1700 80 2040 80 {}
L 4 2040 40 2040 80 {}
L 4 1860 40 1860 80 {}
L 4 1700 80 1700 120 {}
L 4 1700 120 2040 120 {}
L 4 1860 80 1860 120 {}
L 4 2040 80 2040 120 {}
T {specifications tt 27 Cº degrees} 1690 -530 0 0 1 1 {}
T {UGBW} 1740 -430 0 0 0.4 0.4 {}
T {48Mhz} 1920 -430 0 0 0.4 0.4 {}
T {CMRR} 1740 -390 0 0 0.4 0.4 {}
T {79db} 1920 -390 0 0 0.4 0.4 {}
T {dc gain} 1740 -350 0 0 0.4 0.4 {}
T {80 db} 1920 -350 0 0 0.4 0.4 {}
T {ICMR} 1740 -310 0 0 0.4 0.4 {}
T {} 1920 -310 0 0 0.4 0.4 {}
T {0 V - 1.4 V} 1900 -310 0 0 0.4 0.4 {}
T {OUTPUT range} 1710 -270 0 0 0.35 0.35 {}
T {} 1920 -270 0 0 0.4 0.4 {}
T {0.2 V - 1.6 V} 1890 -270 0 0 0.4 0.4 {}
T {phase margin} 1710 -230 0 0 0.4 0.4 {}
T {65º} 1930 -230 0 0 0.4 0.4 {}
T {PSSR+} 1740 -190 0 0 0.4 0.4 {}
T {82 db} 1920 -190 0 0 0.4 0.4 {}
T {84 db} 1920 -150 0 0 0.4 0.4 {}
T {offset at 900mV} 1710 -110 0 0 0.3 0.3 {}
T {Power} 1750 -70 0 0 0.35 0.35 {}
T {PSSR-} 1740 -150 0 0 0.4 0.4 {}
T {10 uV} 1920 -110 0 0 0.4 0.4 {}
T {369 uW} 1920 -70 0 0 0.4 0.4 {}
T {VDD} 1750 -30 0 0 0.35 0.35 {}
T {1.8 V} 1920 -10 2 1 0.4 0.4 {}
T {Cp} 1750 10 0 0 0.35 0.35 {}
T {3p F} 1920 30 2 1 0.4 0.4 {}
T {GBW} 1750 50 0 0 0.35 0.35 {}
T {30 Mhz} 1910 50 0 0 0.4 0.4 {}
T {Dc Gain} 1750 90 0 0 0.35 0.35 {}
T {74 dB} 1910 90 0 0 0.4 0.4 {}
N -370 -770 -300 -770 {
lab=VDD}
N -370 -730 -300 -730 {
lab=VSS}
N -370 -690 -300 -690 {
lab=VIN}
N -370 -650 -300 -650 {
lab=VOUT}
N -370 -610 -300 -610 {
lab=-VOUT}
C {devices/iopin.sym} -370 -770 0 1 {name=p1 lab=VDD}
C {devices/lab_pin.sym} -300 -770 2 0 {name=p4 sig_type=std_logic lab=VDD}
C {devices/iopin.sym} -370 -730 0 1 {name=p6 lab=VSS}
C {devices/lab_pin.sym} -300 -730 2 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/iopin.sym} -370 -690 0 1 {name=p12 lab=VIN}
C {devices/lab_pin.sym} -300 -690 2 0 {name=p13 sig_type=std_logic lab=VIN}
C {devices/iopin.sym} -370 -650 0 1 {name=p17 lab=VOUT}
C {devices/lab_pin.sym} -300 -650 2 0 {name=p18 sig_type=std_logic lab=VOUT}
C {devices/iopin.sym} -370 -610 0 1 {name=p19 lab=-VOUT}
C {devices/lab_pin.sym} -300 -610 2 0 {name=p20 sig_type=std_logic lab=-VOUT}
