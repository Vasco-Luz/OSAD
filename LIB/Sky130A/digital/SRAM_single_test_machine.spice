* SPICE netlist generated by Yosys 0.47+42 (git sha1 6d4f056a3, g++ 11.4.0-1ubuntu1~22.04 -fPIC -O3)

X0 counter_inst.count.0 1.0 sky130_fd_sc_hd__clkinv_1
X1 reset 2 sky130_fd_sc_hd__clkinv_1
X2 counter_inst.count.0 counter_inst.count.1 3 sky130_fd_sc_hd__nand2_1
X3 counter_inst.count.0 counter_inst.count.1 4.1 sky130_fd_sc_hd__xor2_1
X4 counter_inst.count.2 3 4.2 sky130_fd_sc_hd__xnor2_1
X5 counter_inst.count.0 counter_inst.count.1 counter_inst.count.2 counter_inst.count.3 5 sky130_fd_sc_hd__nand4_1
X6 counter_inst.count.0 counter_inst.count.1 counter_inst.count.2 counter_inst.count.3 6 sky130_fd_sc_hd__a31oi_1
X7 5 6 4.3 sky130_fd_sc_hd__lpflow_isobufsrc_1
X8 counter_inst.count.4 5 7 sky130_fd_sc_hd__lpflow_isobufsrc_1
X9 counter_inst.count.4 5 4.4 sky130_fd_sc_hd__xnor2_1
X10 counter_inst.count.5 7 4.5 sky130_fd_sc_hd__xor2_1
X11 reset 8 sky130_fd_sc_hd__clkinv_1
X12 reset 9 sky130_fd_sc_hd__clkinv_1
X13 reset 10 sky130_fd_sc_hd__clkinv_1
X14 reset 11 sky130_fd_sc_hd__clkinv_1
X15 reset 12 sky130_fd_sc_hd__clkinv_1
X16 clk 1.0 counter_inst.count.0 2 sky130_fd_sc_hd__dfrtp_1
X17 clk 4.1 counter_inst.count.1 8 sky130_fd_sc_hd__dfrtp_1
X18 clk 4.2 counter_inst.count.2 9 sky130_fd_sc_hd__dfrtp_1
X19 clk 4.3 counter_inst.count.3 10 sky130_fd_sc_hd__dfrtp_1
X20 clk 4.4 counter_inst.count.4 11 sky130_fd_sc_hd__dfrtp_1
X21 clk 4.5 counter_inst.count.5 12 sky130_fd_sc_hd__dfrtp_1
X22 state_machine_inst.state.1 13 sky130_fd_sc_hd__clkinv_1
X23 reset 14 sky130_fd_sc_hd__clkinv_1
X24 counter_inst.count.0 counter_inst.count.1 15 sky130_fd_sc_hd__and2_0
X25 counter_inst.count.0 counter_inst.count.1 16 sky130_fd_sc_hd__nand2_1
X26 counter_inst.count.2 counter_inst.count.3 counter_inst.count.5 counter_inst.count.4 17 sky130_fd_sc_hd__or4b_1
X27 state_machine_inst.state.1 state_machine_inst.state.0 18 sky130_fd_sc_hd__lpflow_isobufsrc_1
X28 counter_inst.count.0 counter_inst.count.1 19 sky130_fd_sc_hd__lpflow_isobufsrc_1
X29 counter_inst.count.1 counter_inst.count.0 20 sky130_fd_sc_hd__nand2b_1
X30 counter_inst.count.5 counter_inst.count.4 21 sky130_fd_sc_hd__nor2_1
X31 counter_inst.count.2 counter_inst.count.5 counter_inst.count.4 counter_inst.count.3 22 sky130_fd_sc_hd__or4b_1
X32 16 17 20 22 18 23 sky130_fd_sc_hd__o221ai_1
X33 state_machine_inst.state.1 state_machine_inst.state.0 24 sky130_fd_sc_hd__nand2_1
X34 counter_inst.count.2 counter_inst.count.3 19 21 24 25 sky130_fd_sc_hd__a41o_1
X35 state_machine_inst.state.1 state_machine_inst.state.0 26 sky130_fd_sc_hd__nand2b_1
X36 counter_inst.count.3 counter_inst.count.5 counter_inst.count.4 counter_inst.count.2 27 sky130_fd_sc_hd__nor4b_1
X37 counter_inst.count.3 counter_inst.count.5 counter_inst.count.4 counter_inst.count.2 28 sky130_fd_sc_hd__or4b_1
X38 20 28 29 sky130_fd_sc_hd__nor2_1
X39 counter_inst.count.2 counter_inst.count.3 counter_inst.count.5 counter_inst.count.4 30 sky130_fd_sc_hd__nor4_1
X40 19 30 state_machine_inst.state.1 state_machine_inst.state.0 31 sky130_fd_sc_hd__a211o_1
X41 state_machine_inst.state.1 29 25 23 state_machine_inst.state.0 32 sky130_fd_sc_hd__o2111ai_1
X42 13 32 33 sky130_fd_sc_hd__nand2_1
X43 23 31 32 34 sky130_fd_sc_hd__and3_1
X44 counter_inst.count.0 counter_inst.count.1 35 sky130_fd_sc_hd__nor2_1
X45 counter_inst.count.0 counter_inst.count.1 36 sky130_fd_sc_hd__lpflow_inputiso1p_1
X46 17 20 22 36 37 sky130_fd_sc_hd__o22ai_1
X47 16 28 36 17 38 sky130_fd_sc_hd__o22ai_1
X48 counter_inst.count.0 counter_inst.count.1 39 sky130_fd_sc_hd__nand2b_1
X49 counter_inst.count.0 counter_inst.count.3 counter_inst.count.2 counter_inst.count.1 40 sky130_fd_sc_hd__nand4bb_1
X50 counter_inst.count.0 counter_inst.count.1 counter_inst.count.2 counter_inst.count.3 41 sky130_fd_sc_hd__nand4_1
X51 40 41 21 42 sky130_fd_sc_hd__a21boi_0
X52 37 42 38 18 43 sky130_fd_sc_hd__or4b_1
X53 counter_inst.count.1 30 35 27 26 44 sky130_fd_sc_hd__a221oi_1
X54 44 45 sky130_fd_sc_hd__clkinv_1
X55 counter_inst.count.2 counter_inst.count.3 21 35 13 46 sky130_fd_sc_hd__a41o_1
X56 counter_inst.count.2 counter_inst.count.3 21 35 24 47 sky130_fd_sc_hd__a41oi_1
X57 22 39 47 48 sky130_fd_sc_hd__o21ai_0
X58 29 45 48 31 43 49 sky130_fd_sc_hd__o2111ai_1
X59 16 22 47 50 sky130_fd_sc_hd__o21ai_0
X60 23 37 45 50 31 51 sky130_fd_sc_hd__o2111ai_1
X61 13 state_machine_inst.state.0 15 30 47 52 sky130_fd_sc_hd__a41oi_1
X62 23 52 53 sky130_fd_sc_hd__nand2_1
X63 37 38 18 54 sky130_fd_sc_hd__o21ai_0
X64 state_machine_inst.state.0 46 55 sky130_fd_sc_hd__nand2_1
X65 54 55 56 sky130_fd_sc_hd__nand2_1
X66 state_machine_inst.state.0 27 57 sky130_fd_sc_hd__nand2_1
X67 counter_inst.count.1 57 54 24 58 sky130_fd_sc_hd__o211ai_1
X68 reset 59 sky130_fd_sc_hd__clkinv_1
X69 58 49 state_machine_inst.B_line __DLATCH_N_
X70 53 51 state_machine_inst.wr __DLATCH_N_
X71 56 49 state_machine_inst.B_line_neg __DLATCH_N_
X72 clk 34 state_machine_inst.state.0 14 sky130_fd_sc_hd__dfrtp_1
X73 clk 33 state_machine_inst.state.1 59 sky130_fd_sc_hd__dfrtp_1
V0 clk state_machine_inst.clk DC 0
V1 counter_inst.count.0 state_machine_inst.count.0 DC 0
V2 counter_inst.count.1 state_machine_inst.count.1 DC 0
V3 counter_inst.count.2 state_machine_inst.count.2 DC 0
V4 counter_inst.count.3 state_machine_inst.count.3 DC 0
V5 counter_inst.count.4 state_machine_inst.count.4 DC 0
V6 counter_inst.count.5 state_machine_inst.count.5 DC 0
V7 reset state_machine_inst.reset DC 0
V8 counter_inst.count.1 1.1 DC 0
V9 counter_inst.count.2 1.2 DC 0
V10 counter_inst.count.3 1.3 DC 0
V11 counter_inst.count.4 1.4 DC 0
V12 counter_inst.count.5 1.5 DC 0
V13 1.0 4.0 DC 0
V14 clk counter_inst.clk DC 0
V15 reset counter_inst.reset DC 0
V16 state_machine_inst.B_line B_line DC 0
V17 state_machine_inst.B_line_neg B_line_neg DC 0
V18 counter_inst.count.0 count.0 DC 0
V19 counter_inst.count.1 count.1 DC 0
V20 counter_inst.count.2 count.2 DC 0
V21 counter_inst.count.3 count.3 DC 0
V22 counter_inst.count.4 count.4 DC 0
V23 counter_inst.count.5 count.5 DC 0
V24 state_machine_inst.wr wr DC 0

************************
* end of SPICE netlist *
************************
