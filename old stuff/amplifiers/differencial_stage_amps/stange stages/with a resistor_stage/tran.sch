v {xschem version=3.4.2 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
